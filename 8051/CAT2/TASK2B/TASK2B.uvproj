# Keil uVision project TASK2B.uvproj, settings and files
target TASK2B (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: TASK2B +hex
  group Source Group 1
    ./: main.c delay.c STARTUP.A51
