# Keil uVision project TASK7B.uvproj, settings and files
target TASK7B (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: TASK7B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c lcd.c lcd.h
